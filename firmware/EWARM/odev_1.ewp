# IAR project odev_1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F407xx; HSE_VALUE=8000000
  ICCARM.CCIncludePath2: ..\Core\Inc; ..\Drivers\CMSIS\Include; ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\Middlewares\FreeRTOS-Kernel\include; ..\Middlewares\FreeRTOS-Kernel\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Core\Inc
  ILINK.IlinkOutputFile: odev_1.out
  ILINK.IlinkIcfFile: stm32f407vg_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; STM32F407xx; HSE_VALUE=8000000
  ICCARM.CCOptLevel: 3
  group Application
    ../Core/Src/: button.c button_task.c command.c main.c protocol.c stats.c stm32f4xx_it.c system_clock.c telemetry_task.c temp_sensor.c timestamp.c uart.c uart_tx_task.c workload.c
  group CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Config
    ../Core/Inc/: FreeRTOSConfig.h main.h
  group FreeRTOS
    ../Middlewares/FreeRTOS-Kernel/: list.c queue.c tasks.c
  group FreeRTOS/portable
    ../Middlewares/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
    ../Middlewares/FreeRTOS-Kernel/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Startup
    ../Core/Startup/: startup_stm32f407xx.s
